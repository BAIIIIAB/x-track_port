# Keil uVision project GD32F470.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F470 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Hardware\LED;..\Hardware\LCD;..\Hardware\SDRAM;..\Hardware\DEBUG;..\Hardware\KEY;..\Hardware\TOUCH;..\Hardware\SDCARD;..\App;..\Middleware\LVGL\GUI\lvgl;..\Middleware\LVGL\GUI\lvgl\src;..\Middleware\LVGL\GUI\lvgl\examples\porting
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_timer.c gd32f4xx_adc.c gd32f4xx_i2c.c gd32f4xx_spi.c gd32f4xx_exti.c gd32f4xx_crc.c gd32f4xx_misc.c gd32f4xx_dac.c gd32f4xx_exmc.c gd32f4xx_tli.c gd32f4xx_dma.c gd32f4xx_syscfg.c gd32f4xx_sdio.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Hardware
    ../Hardware/LCD/: lcd.c
    ../Hardware/SDRAM/: exmc_sdram.c
    ../Hardware/touch/: touch.c
    ../Hardware/LED/: led.c
    ../Hardware/KEY/: key.c
    ../Hardware/DEBUG/: driver_debug.c driver_dma.c
    ../Hardware/SDCARD/: sdcard.c
  group App
    ../App/: sd_test.c
  group lv_port
    ../Middleware/LVGL/GUI/lvgl/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group lv_core
    ../Middleware/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lv_draw
    ../Middleware/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lv_extra
    ../Middleware/LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
  group lv_font
    ../Middleware/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lv_gpu
    ../Middleware/LVGL/GUI/lvgl/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Middleware/LVGL/GUI/lvgl/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ../Middleware/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group lv_hal
    ../Middleware/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../Middleware/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lv_widgets
    ../Middleware/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lv_example
    ../Middleware/LVGL/demos/widgets/: lv_demo_widgets.c
